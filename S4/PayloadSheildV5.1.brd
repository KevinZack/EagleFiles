File: S4/PayloadSheildV5.1.brd (EAGLE design)
At the start: 184.2 x 63.5 mm, 20 parts, among them U2 ARDUINOR3

Commit message: Updated S4 Files + garber
Routing:
- net GND: track 455.1 -> 454.3 mm
